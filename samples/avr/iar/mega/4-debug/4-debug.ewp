# IAR project 4-debug.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328 ATmega328
  ICCAVR.CCDefines: F_CPU=7372800UL; ENABLE_BIT_DEFINITIONS
  ICCAVR.newCCIncludePaths: ..\common\; src\; ..\..\..\..\..\scmRTOS\core\; ..\..\..\..\..\scmRTOS\ext\profiler\; ..\..\..\..\..\scmRTOS\port\avr\iar
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: ENABLE_BIT_DEFINITIONS
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group inc
    ../../../../../scmRTOS/core/: os_kernel.h os_services.h scmRTOS.h scmRTOS_defs.h usrlib.h
    ../../../../../scmRTOS/port/avr/iar/: os_target.h
    ../common/: pin_macros.h
    ../../../../../scmRTOS/ext/profiler/: profiler.h
    src/: scmRTOS_CONFIG.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h
  group src
    src/: debug.cpp main.cpp prio_names.cpp
    ../../../../../scmRTOS/core/: os_kernel.cpp os_services.cpp usrlib.cpp
    ../../../../../scmRTOS/port/avr/iar/: os_target.cpp os_target_asm.s90
