# IAR project slon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\scmRTOS\core\; ..\..\..\..\..\scmRTOS\ext\profiler\; ..\..\..\..\..\scmRTOS\\port\cortex\m3-iar\; src\; ..\common\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\scmRTOS\Common\; ..\scmRTOS\CortexM3\; src\
  OBJCOPY.OOCOutputFile: slon.srec
  ILINK.IlinkOutputFile: slon.out
  ILINK.IlinkIcfFile: ..\common\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: as above
  group (top)
    src/: main.cpp scmRTOS_config.h scmRTOS_TARGET_CFG.h
  group scmRTOS/core
    ../../../../../scmRTOS/core/: os_kernel.cpp OS_Kernel.h os_services.cpp OS_Services.h scmRTOS.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/port
    ../../../../../scmRTOS/port/cortex/m3-iar/: os_target.cpp OS_Target.h os_target_asm.s
  group common
    ../common/: startup_stm32f10x_md.s SystemInit.c
