<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\event-flag-m3-lpc1768.ewp</path>
    </project>
    <batchBuild />
</workspace>
