<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\event-flag-m4f-nucleo-f334r8.ewp</path>
    </project>
    <batchBuild />
</workspace>
