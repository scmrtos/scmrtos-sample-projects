# IAR project watchdog-m0-stm32f091rbt6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RB ST STM32F091RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.IExtraOptions: --warnings_are_errors
  ICCARM.CCIncludePath2: src; ..\..\..\..\scmRTOS\core; ..\..\..\..\scmRTOS\port\cortex\mx-iar; ..\..\..\..\scmRTOS\ext\profiler; ..\..\..\..\scmRTOS\ext\watchdog
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: event-flag-stm32f051-sample.out
  ILINK.IlinkIcfFile: src\stm32f091rbt6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group scmRTOS/core
    ../../../../scmRTOS/core/: os_kernel.cpp os_kernel.h os_services.cpp os_services.h scmRTOS.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/port/cortex/mx-iar
    ../../../../scmRTOS/port/cortex/mx-iar/: os_target.cpp os_target.h os_target_asm.S
  group src
    src/: main.cpp scmRTOS_CONFIG.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h stm32f091_startup.cpp stm32f091rbt6.icf
