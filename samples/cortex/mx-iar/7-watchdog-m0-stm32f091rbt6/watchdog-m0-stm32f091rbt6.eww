<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\watchdog-m0-stm32f091rbt6.ewp</path>
    </project>
    <batchBuild />
</workspace>
