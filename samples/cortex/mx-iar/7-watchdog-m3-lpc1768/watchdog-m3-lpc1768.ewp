# IAR project watchdog-m3-lpc1768.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: --warnings_are_errors
  ICCARM.CCIncludePath2: src; ..\..\..\..\scmRTOS\core; ..\..\..\..\scmRTOS\port\cortex\mx-iar; ..\..\..\..\scmRTOS\ext\profiler; ..\..\..\..\scmRTOS\ext\watchdog
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: watchdog-m3-lpc1768.out
  ILINK.IlinkIcfFile: src\lpc1768.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group scmRTOS/core
    ../../../../scmRTOS/core/: os_kernel.cpp os_kernel.h os_services.cpp os_services.h scmRTOS.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/port/cortex/mx-iar
    ../../../../scmRTOS/port/cortex/mx-iar/: os_target.cpp os_target.h os_target_asm.S
  group src
    src/: lpc1768.icf lpc1768_startup.cpp main.cpp scmRTOS_CONFIG.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h
