# IAR project slon.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F2617 MSP430F2617
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: F2617
  ICC430.newCCIncludePaths: src\; ..\..\..\..\..\scmRTOS\core\; ..\..\..\..\..\scmRTOS\port\msp430\iar
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 1
  A430.ADefines: F2617; __CORE__=1
  A430.AUserIncludes: Src\; ..\..\scmRTOS\Common\; ..\..\scmRTOS\MSP430\
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f2617.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    src/: main.cpp
    ../../../../../scmRTOS/core/: os_kernel.cpp os_services.cpp usrlib.cpp
    ../../../../../scmRTOS/port/msp430/iar/: os_target.cpp os_target_asm.s43
