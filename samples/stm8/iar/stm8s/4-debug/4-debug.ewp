# IAR project 4-debug.ewp, settings and files
configuration STM8S105C6 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: F_MASTER=16000000; STM8S105
  ICCSTM8.CCIncludePath2: src\; ..\..\..\..\..\scmRTOS\core\; ..\..\..\..\..\scmRTOS\ext\profiler\; ..\..\..\..\..\scmRTOS\port\stm8\iar\; ..\STM8S_StdPeriph_Driver\; ..\STM8S_StdPeriph_Driver\inc\; ..\common\
  ICCSTM8.IccLang: 1
  ASTM8.AsmIncludePath: src
  OBJCOPY.OOCOutputFile: 4-debug.hex
  ILINK.IlinkOutputFile: 1-EventFlag.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: debug.cpp debug.h main.cpp prio_names.cpp prio_names.h scmRTOS_CONFIG.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h
    ../../../../../scmRTOS/core/: os_kernel.cpp os_kernel.h os_services.cpp os_services.h scmRTOS.h scmRTOS_310_compat.h scmRTOS_defs.h usrlib.cpp usrlib.h
    ../../../../../scmRTOS/port/stm8/iar/: os_target.cpp os_target.h os_target_asm.s
    ../../../../../scmRTOS/ext/profiler/: profiler.h
